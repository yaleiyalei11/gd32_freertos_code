# Keil uVision project demo_freertos.uvprojx, settings and files
target demo_freertos (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: GD32F303ZK GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo_freertos +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, GD32F30X_XD
  c include: ..\inc;..\lib\CMSIS\GD\GD32F30x\Include;..\lib\GD32F30x_standard_peripheral\Include;..\lib\CMSIS;..\usr;..\freertos\include;..\freertos\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group usr
    ./: main.c isr.c systick.c
  group inc
    ../inc/: led.h usart.h timer.h
  group src
    ../src/: led.c usart.c timer.c
  group driver
    ../lib/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group startup
    ./: startup_gd32f30x_hd.s
  group cmsis
    ./: system_gd32f30x.c
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Freertos_PORTABLE
    ../freertos/portable/MemMang/: heap_4.c
    ../freertos/portable/RVDS/ARM_CM4F/: port.c
